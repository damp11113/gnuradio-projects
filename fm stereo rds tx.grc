options:
  parameters:
    generate_options: qt_gui
    id: fmstereords
    output_language: python
    title: FM stereo
  states: {}

blocks:
- name: fm_max_dev
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: inaudiogain
  id: variable_qtgui_range
  parameters:
    label: In-Audio Gain
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: inaudioscagain
  id: variable_qtgui_range
  parameters:
    label: SCA In-Audio Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: 2000 / fm_max_dev
  states: {}
- name: rdsena
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: RDS
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: rdsgain
  id: variable_qtgui_range
  parameters:
    label: RDS Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: scaamp
  id: variable_qtgui_range
  parameters:
    label: SCA FM amp
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: scaena
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: SCA
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: stereoena
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Stereo
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: subtrack
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '2'
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: inaudioscagain
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.03'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: subtrack
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: scaamp
    freq: '67000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: '"Line 5 (Virtual Audio Cable)"'
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: '"Line 6 (Virtual Audio Cable)"'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: '"Line 3 (Virtual Audio Cable)"'
    num_outputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_0_0
  id: audio_source
  parameters:
    device_name: '"Line 3 (Virtual Audio Cable)"'
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: inaudiogain
    high_cutoff_freq: '15000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: inaudiogain
    high_cutoff_freq: '15000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_1
  id: band_pass_filter
  parameters:
    gain: inaudiogain
    high_cutoff_freq: '10000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not(stereoena)
    type: float
  states: {}
- name: blocks_mute_xx_0_0
  id: blocks_mute_xx
  parameters:
    mute: not(rdsena)
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\sansw\Desktop\Skillet- Feel Invincible (join missing from broken transmitter).wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: ddsasds
  id: blocks_mute_xx
  parameters:
    mute: not(scaena)
    type: float
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: complex
  states: {}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: rdsgain
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    clock_source0: external_1pps
    freq0: 107.5e6
    gain0: '47'
    if_gain0: '20'
    sample_rate: samp_rate*50
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: RDS Output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 107.5e6
    ms: 'True'
    pi_country_code: '8'
    pi_coverage_area: '0'
    pi_reference_number: '51442'
    ps: DPRadio
    pty: '11'
    pty_locale: '0'
    radiotext: Testing software modulation. TX with SDR
    ta: 'False'
    tp: 'True'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: 150*rdsgain
    interp: '160'
    ntaps: 160*11
    samp_rate: samp_rate
    sym_rate: '2375'
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_fm_deemph_0, '0', analog_wfm_tx_0, '0']
- [analog_fm_deemph_0, '0', qtgui_sink_x_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_wfm_tx_0, '0', blocks_complex_to_float_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0_0, '0', band_pass_filter_0_0_0, '0']
- [audio_source_0_0, '1', band_pass_filter_0_0, '0']
- [audio_source_0_0_0, '0', band_pass_filter_0_0_1, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_1, '0']
- [band_pass_filter_0_0, '0', blocks_sub_xx_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_1, '1']
- [band_pass_filter_0_0_0, '0', blocks_sub_xx_0, '1']
- [band_pass_filter_0_0_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_mute_xx_0, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0_0, '1']
- [blocks_complex_to_float_1, '0', ddsasds, '0']
- [blocks_complex_to_float_2, '0', blocks_mute_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_float_1, '0']
- [blocks_mute_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_mute_xx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_null_source_0, '0', blocks_add_xx_0, '3']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_wavfile_source_0, '1', band_pass_filter_0_0, '0']
- [ddsasds, '0', blocks_add_xx_0, '3']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_complex_to_float_2, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [root_raised_cosine_filter_0, '0', gr_multiply_xx_0, '1']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
